# Keil uVision project STM32-DEMO.uvproj, settings and files
target LED-DEMO (ARM-ADS)
  device: STM32F103T6 STMicroelectronics
  cpu: IRAM(0x20000000-0x200027FF) IROM(0x8000000-0x8007FFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: STM32-DEMO +hex
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER, STM32F10X_HD
  c include: ..\CMSIS;..\USER;..\FWlib\inc;..\FWlib\src
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x2800
  group STARTUPCODE
    ../CMSIS/startup/: startup_stm32f10x_hd.s
  group USER
    ./: main.c stm32f10x_it.c exti.c led.c pwm_output.c
  group FWlib
    ../FWlib/src/: stm32f10x_rcc.c stm32f10x_gpio.c stm32f10x_exti.c misc.c stm32f10x_tim.c
  group CMSIS
    ../CMSIS/: core_cm3.c system_stm32f10x.c
